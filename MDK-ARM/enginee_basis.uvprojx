# Keil uVision project enginee_basis.uvprojx, settings and files
target enginee_basis (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: enginee_basis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../IFR_LIB-V4.0-main;../other_core/Math;../engine_car/overall_car_control;../other_core;../engine_car/car_basis;../other_core/state_machine;../IFR_LIB-V4.0-main/IMU;../IFR_LIB-V4.0-main/judge;../engine_car/car_arm
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group IFR_LIB-V4.0-main
    ../IFR_LIB-V4.0-main/: ifr_crc.c ifr_remote.c ifr_basic_math.cpp ifr_can.cpp ifr_djimotor.cpp ifr_dmmotor.cpp ifr_extra.cpp ifr_fdcan.cpp ifr_gpio.cpp ifr_key.cpp ifr_pid.cpp ifr_pwm.cpp ifr_rsmotor.cpp ifr_state_machine.cpp ifr_sys_time.cpp ifr_tim.cpp ifr_usart.cpp
  group Math
    ../other_core/Math/: Math_calculate.cpp Math_calculate.h matrix_math.cpp matrix_math.h Transition_type.cpp Transition_type.h
  group overall_car_control
    ../engine_car/overall_car_control/: Receive_remote_ifr.cpp Receive_remote_ifr.h Init_engine_car.cpp Init_engine_car.h
  group state_machine
    ../other_core/state_machine/: Function_flag.h Self_state_machine.cpp Self_state_machine.h
  group other_core
    ../other_core/: self_codebase_include.h
  group car_basis
    ../engine_car/car_basis/: car_basis_control.cpp car_basis_control.h
  group IMU
    ../IFR_LIB-V4.0-main/IMU/: bmi088.cpp bmi088.h BMI088reg.h IMU_DM.cpp IMU_DM.h
  group judge
    ../IFR_LIB-V4.0-main/judge/: Judge.cpp Judge.h
  group car_arm
    ../engine_car/car_arm/: Arm_calculate_basis.cpp Arm_calculate_basis.h arm_inverse_kinematics.cpp arm_inverse_kinematics.h car_arm_control.cpp car_arm_control.h Init_car_arm.cpp Init_car_arm.h trajectory_planning.cpp trajectory_planning.h
software components: CMSIS:CORE 4.3.0
